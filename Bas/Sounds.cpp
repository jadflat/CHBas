// The cart's sound on CHGame's piezo (Sounds.h): the effects and songs
// tools/p8audio.py made from the cart (src/audio/Audio.*).
#include <chgame/Audio.h>
#include "config.h"
#include "Sounds.h"
#include "src/audio/Audio.h"     // SOUNDS, Sfx, Song (generated by tools/p8audio.py)

namespace snd {

void begin() {
    audio::begin(SOUNDS, cartaudio::EFFECT_COUNT);
    audio::setMusic(audio::LEAD);       // the tune, the second voice in its rests
}

void sfx(int n, int ch) {
    (void)ch;
    if (n < 0) return;      // sfx(-1, ch): the effects are short; the piezo lets one finish
    if (n < 64 && cartaudio::SFX_EFFECT[n] != 0xFF) audio::sfx(cartaudio::SFX_EFFECT[n]);
}

// The fade is the cart's; the piezo stops at once.
void music(int n, int) {
#if BAS_MUSIC
    if (n < 0) audio::stopMusic();
    else if (n == 0) playSong(Song::TITLE, true);
    else if (n == 2) playSong(Song::PLAY, true);
#else
    (void)n;
#endif
}

}  // namespace snd

void playSong(Song s, bool loop) { audio::music(cartaudio::SONGS[(uint8_t)s], loop); }
